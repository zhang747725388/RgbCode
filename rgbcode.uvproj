# Keil uVision project rgbcode.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5410AD STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x27FF) CLOCK(45000000)
  output: rgbcode +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\APP;.\BSP;..\..\CodeGroup;..\rgbcode
  asm include: ..\rgbcode;.\APP;.\BSP;..\..\CodeGroup
  group Source Group 1
    ./: STARTUP.A51
  group Kernal
    ./BSP/: delay.c Timer.c USART.C
  group BSP
    ./BSP/: GPIO.c TLC5620.c key.c PCA.c Pwm.c USART.C
  group APP
    ./APP/: Task.c SetChannel.c KeyAction.c Model.c
  group Main
    ./: Main.c
